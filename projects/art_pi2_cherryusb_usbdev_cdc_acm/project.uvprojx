# Keil uVision project project.uvprojx, settings and files
target rt-thread (6140001::V6.14.1::ARMCLANG)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5
  c define: RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, USE_HAL_DRIVER, __RTTHREAD__, STM32H7S7xx, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC
  c include: libraries\bsp_components;packages\CherryUSB-latest\class\msc;packages\CherryUSB-latest\class\midi;rt-thread\components\drivers\include;board\CubeMX_Config\Appli\Core\Inc;libraries\CMSIS\Include;rt-thread\components\libc\posix\io\epoll;packages\CherryUSB-latest\class\adb;packages\CherryUSB-latest\class\hub;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\libc\posix\io\eventfd;packages\CherryUSB-latest\class\hid;rt-thread\components\finsh;packages\CherryUSB-latest;rt-thread\components\drivers\include;packages\CherryUSB-latest\class\video;rt-thread\components\drivers\include;board\port;rt-thread\include;rt-thread\components\libc\compilers\common\extension;packages\CherryUSB-latest\class\dfu;rt-thread\libcpu\arm\common;libraries\STM32H7RSxx_HAL_Driver\Inc;libraries\CMSIS\Device\ST\STM32H7RSxx\Include;packages\CherryUSB-latest\class\vendor\net;packages\CherryUSB-latest\class\wireless;applications;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\include;.;packages\CherryUSB-latest\common;packages\CherryUSB-latest\osal;libraries\drivers\include\config;libraries\drivers\include;rt-thread\components\libc\posix\ipc;packages\CherryUSB-latest\core;libraries\drivers;rt-thread\components\libc\posix\io\poll;packages\CherryUSB-latest\class\vendor\wifi;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\dfs\dfs_v1\include;packages\CherryUSB-latest\class\vendor\serial;rt-thread\components\dfs\dfs_v1\filesystems\devfs;board;packages\CherryUSB-latest\class\audio;packages\CherryUSB-latest\class\cdc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CherryUSB
    packages/CherryUSB-latest/platform/rtthread/: usb_msh.c usb_check.c
    packages/CherryUSB-latest/core/: usbd_core.c
    packages/CherryUSB-latest/port/dwc2/: usb_glue_st.c usb_dc_dwc2.c
    packages/CherryUSB-latest/class/cdc/: usbd_cdc_acm.c
    packages/CherryUSB-latest/demo/: cdc_acm_template.c
    packages/CherryUSB-latest/osal/: usb_osal_rtthread.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
  group Drivers
    board/CubeMX_Config/Appli/Core/Src/: stm32h7rsxx_hal_msp.c
    board/: board.c drv_mpu.c
    board/port/: filesystem.c
    libraries/drivers/: drv_common.c drv_gpio.c drv_psram.c drv_spi.c drv_usart.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: msh_parse.c cmd.c msh.c msh_file.c shell.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group STM32_HAL
    libraries/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_crc.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_hal_cryp_ex.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_usart.c stm32h7rsxx_hal_crc_ex.c stm32h7rsxx_hal_sram.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_cec.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_cryp.c stm32h7rsxx_hal_rng.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_flash_ex.c
    libraries/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/: system_stm32h7rsxx.c
    libraries/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/arm/: startup_stm32h7r7xx.s
