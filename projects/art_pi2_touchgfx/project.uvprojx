# Keil uVision project project.uvprojx, settings and files
target rt-thread (6190000::V6.19::ARMCLANG)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3
  c define: RT_USING_LIBC, USE_HAL_DRIVER, __RTTHREAD__, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, STM32H7S7xx, __CLK_TCK=RT_TICK_PER_SECOND
  c include: libraries\touchgfx_lib\Middlewares\ST\touchgfx_components\gpu2d\NemaGFX\include;libraries\touchgfx_lib\TouchGFX\gui\include;packages\FreeRTOS_Wrapper-latest\FreeRTOS\include;board\CubeMX_Config\Appli\Core\Inc;rt-thread\components\drivers\include;libraries\touchgfx_lib\TouchGFX\target;libraries\touchgfx_lib\Middlewares\ST\touchgfx\framework\include;rt-thread\components\drivers\include;rt-thread\components\drivers\touch;rt-thread\libcpu\arm\cortex-m7;libraries\drivers\include\config;rt-thread\components\dfs\dfs_v1\include;libraries\touchgfx_lib\TouchGFX\generated\gui_generated\include;rt-thread\components\libc\posix\io\epoll;board;rt-thread\libcpu\arm\common;rt-thread\components\libc\posix\io\eventfd;libraries\touchgfx_lib\TouchGFX\target\generated;rt-thread\components\libc\posix\ipc;libraries\bsp_components;rt-thread\components\dfs\dfs_v1\filesystems\devfs;libraries\touchgfx_lib\TouchGFX\generated\texts\include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;libraries\drivers\include;libraries\drivers;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\include;rt-thread\include;libraries\touchgfx_lib\TouchGFX\generated\fonts\include;libraries\touchgfx_lib\TouchGFX\generated\images\include;.;applications;libraries\CMSIS\Device\ST\STM32H7RSxx\Include;rt-thread\components\drivers\spi\sfud\inc;libraries\CMSIS\Include;rt-thread\components\drivers\spi;rt-thread\components\libc\compilers\common\extension;rt-thread\components\drivers\include;libraries\STM32H7RSxx_HAL_Driver\Inc;board\port;rt-thread\components\drivers\include;libraries\touchgfx_lib\TouchGFX;libraries\touchgfx_lib\Middlewares\Third_Party\CMSIS_RTOS_V2;packages\gt911-latest\inc;libraries\touchgfx_lib\TouchGFX\generated\videos\include;rt-thread\components\libc\posix\io\poll;rt-thread\components\dfs\dfs_v1\filesystems\romfs;packages\FreeRTOS_Wrapper-latest\FreeRTOS\portable\rt-thread;packages\FreeRTOS_Wrapper-latest\FreeRTOS\include\freertos;rt-thread\components\drivers\include;libraries\touchgfx_lib\Middlewares\ST\touchgfx\framework\include\touchgfx;rt-thread\components\drivers\include;libraries\touchgfx_lib\Middlewares\ST\touchgfx_components\gpu2d\TouchGFXNema\include;rt-thread\components\finsh;libraries\CMSIS\RTOS2\Include;rt-thread\components\drivers\include;rt-thread\components\libc\cplusplus
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    rt-thread/components/libc/cplusplus/: cxx_crt_init.c cxx_crt.cpp
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/touch/: touch.c
  group Drivers
    board/CubeMX_Config/Appli/Core/Src/: stm32h7rsxx_hal_msp.c
    board/: board.c drv_mpu.c
    board/port/: filesystem.c
    libraries/drivers/: drv_common.c drv_gpio.c drv_psram.c drv_soft_i2c.c drv_spi.c drv_usart.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: msh_parse.c cmd.c shell.c msh.c msh_file.c
  group FreeRTOS
    packages/FreeRTOS_Wrapper-latest/FreeRTOS/: tasks.c timers.c event_groups.c queue.c list.c
    packages/FreeRTOS_Wrapper-latest/FreeRTOS/portable/rt-thread/: port.c
  group gt911
    packages/gt911-latest/src/: gt911.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group STM32_HAL
    libraries/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cryp.c stm32h7rsxx_hal_dma2d.c stm32h7rsxx_hal_gfxmmu.c stm32h7rsxx_hal_spi.c stm32h7rsxx_hal_ltdc.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_cec.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_cryp_ex.c stm32h7rsxx_hal_crc.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal.c stm32h7rsxx_hal_usart.c stm32h7rsxx_hal_gpu2d.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_rng.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_jpeg.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_icache.c stm32h7rsxx_hal_crc_ex.c stm32h7rsxx_hal_sram.c
    libraries/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/arm/: startup_stm32h7r7xx.s
    libraries/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/: system_stm32h7rsxx.c
  group TouchGFX/app
    libraries/touchgfx_lib/TouchGFX/App/: app_touchgfx.c sample_touchgfx.c
    libraries/touchgfx_lib/Middlewares/ST/touchgfx_components/gpu2d/NemaGFX/lib/core/cortex_m7/Keil6.x/: nemagfx_core_release-wchar16.lib
    libraries/touchgfx_lib/Middlewares/ST/touchgfx_components/gpu2d/TouchGFXNema/lib/cortex_m7/Keil6.x/: touchgfxnema_release-wchar16.lib
    libraries/touchgfx_lib/Middlewares/ST/touchgfx/lib/core/cortex_m7/Keil6.x/: touchgfx_core_wchar16.lib
  group TouchGFX/generated
    libraries/touchgfx_lib/TouchGFX/generated/images/src/DiceDemo/: image_dice_left_right_bar.cpp image_scale_slider_bar.cpp image_icon_dice_left_pressed.cpp image_dice_large_3.cpp image_slider_main_bar.cpp image_icon_dice_up_normal.cpp image_dice_large_5.cpp image_icon_dice_down_normal.cpp image_icon_simple_dice_normal.cpp image_dice_large_1.cpp image_dice_large_6.cpp image_toggle_main_bar.cpp image_icon_simple_dice_selected.cpp image_icon_dice_right_normal.cpp image_dice_large_2.cpp image_dice_neochrome_toggle_button_off_notxt.cpp image_icon_adv_dice_selected.cpp image_top_bar.cpp image_scale_slider_fill.cpp image_dice_large_4.cpp image_dice_top_bottom_bar.cpp image_icon_dice_right_pressed.cpp image_icon_scale_small.cpp image_icon_dice_down_pressed.cpp image_background_with_sparkles.cpp image_toggle_marker.cpp image_icon_dice_up_pressed.cpp image_dice_neochrome_toggle_button_on_notxt.cpp image_icon_adv_dice_normal.cpp image_icon_dice_left_normal.cpp image_icon_scale_large.cpp image_scale_slider_knob.cpp
    libraries/touchgfx_lib/TouchGFX/generated/fonts/src/: Font_ShareTechMono_Regular_65_4bpp_0.cpp Kerning_SairaCondensed_SemiBold_16_4bpp.cpp Kerning_ShareTechMono_Regular_20_4bpp.cpp CachedFont.cpp Table_SairaCondensed_SemiBold_26_4bpp.cpp UnmappedDataFont.cpp ApplicationFontProvider.cpp Kerning_ShareTechMono_Regular_90_4bpp.cpp Font_Saira_Medium_11_4bpp_0.cpp Font_SairaCondensed_Medium_32_4bpp_0.cpp Table_ShareTechMono_Regular_36_4bpp.cpp Font_Saira_SemiCondensed_SemiBold_32_4bpp_0.cpp Kerning_ShareTechMono_Regular_120_4bpp.cpp Table_SairaCondensed_Medium_65_4bpp.cpp Font_ShareTechMono_Regular_20_4bpp_0.cpp Table_Saira_Medium_20_4bpp.cpp VectorFontRendererBuffers.cpp Kerning_SairaCondensed_SemiBold_22_4bpp.cpp Kerning_ShareTechMono_Regular_26_4bpp.cpp Table_ShareTechMono_Regular_48_4bpp.cpp Kerning_SairaCondensed_SemiBold_26_4bpp.cpp Table_Saira_SemiCondensed_SemiBold_32_4bpp.cpp Table_Saira_SemiBold_30_4bpp.cpp Font_ShareTechMono_Regular_120_4bpp_0.cpp Font_SairaCondensed_SemiBold_26_4bpp_0.cpp Font_ShareTechMono_Regular_36_4bpp_0.cpp Kerning_ShareTechMono_Regular_36_4bpp.cpp Font_SairaCondensed_Medium_65_4bpp_0.cpp Table_ShareTechMono_Regular_90_4bpp.cpp Font_ShareTechMono_Regular_90_4bpp_0.cpp Kerning_SairaCondensed_SemiBold_38_4bpp.cpp Table_ShareTechMono_Regular_120_4bpp.cpp Table_ShareTechMono_Regular_55_4bpp.cpp Font_SairaCondensed_SemiBold_16_4bpp_0.cpp Kerning_Saira_Medium_11_4bpp.cpp Font_SairaCondensed_SemiBold_38_4bpp_0.cpp Kerning_ShareTechMono_Regular_65_4bpp.cpp Kerning_ShareTechMono_Regular_48_4bpp.cpp Font_Saira_Medium_20_4bpp_0.cpp Kerning_ShareTechMono_Regular_55_4bpp.cpp Font_Saira_SemiBold_30_4bpp_0.cpp Table_ShareTechMono_Regular_65_4bpp.cpp Font_ShareTechMono_Regular_26_4bpp_0.cpp Font_SairaCondensed_SemiBold_22_4bpp_0.cpp Kerning_Saira_Medium_20_4bpp.cpp Table_ShareTechMono_Regular_20_4bpp.cpp Font_ShareTechMono_Regular_48_4bpp_0.cpp FontCache.cpp Table_SairaCondensed_Medium_32_4bpp.cpp Kerning_Saira_SemiBold_30_4bpp.cpp Table_ShareTechMono_Regular_26_4bpp.cpp Font_ShareTechMono_Regular_55_4bpp_0.cpp Kerning_SairaCondensed_Medium_32_4bpp.cpp Table_SairaCondensed_SemiBold_16_4bpp.cpp Kerning_Saira_SemiCondensed_SemiBold_32_4bpp.cpp Table_SairaCondensed_SemiBold_22_4bpp.cpp Kerning_SairaCondensed_Medium_65_4bpp.cpp Table_SairaCondensed_SemiBold_38_4bpp.cpp GeneratedFont.cpp Table_Saira_Medium_11_4bpp.cpp
    libraries/touchgfx_lib/TouchGFX/generated/images/src/ScreenTransitionDemo/: image_background_night_full.cpp image_icon_tab_close.cpp image_toggle_speed_bg.cpp image_trans_top_bar.cpp image_transitions_neochrome_toggle_button_off_notxt.cpp image_background_day_full.cpp image_transitions_neochrome_toggle_button_on_notxt.cpp image_icon_play_dark.cpp image_transitionType1.cpp image_trans_bund_gradient_overlay_1.cpp image_icon_tab_mini_slider.cpp image_transitionType2.cpp image_trans_bund_gradient_overlay_2.cpp image_transitionType3.cpp image_trans_bund_bg.cpp image_transitionType4.cpp image_trans_bund_tab.cpp image_emptyBottombarBg.cpp image_transitionType5.cpp image_icon_speed_slider.cpp
    libraries/touchgfx_lib/TouchGFX/generated/images/src/ebike-screen/: image_button_kmh_normal.cpp image_main_background_numbers_mph.cpp image_battery_steps_full.cpp image_speedometer_needle.cpp image_back_button_normal_ebike.cpp image_mode_sport_inactive.cpp image_battery_steps_low.cpp image_max_button_active.cpp image_battery_steps_2of6.cpp image_button_mph_normal.cpp image_battery_steps_3of6.cpp image_neochrom_button_off.cpp image_button_kmh_pressed.cpp image_neochrom_switch_ebike.cpp image_button_mph_pressed.cpp image_off_button_active.cpp image_graph_Overlay.cpp image_mode_sport_active.cpp image_battery_steps_4of6.cpp image_off_button_normal.cpp image_max_button_normal.cpp image_remaining.cpp image_back_button_pressed_ebike.cpp image_battery_steps_5of6.cpp image_compass.cpp image_standard_button_active.cpp image_main_background_numbers.cpp image_speedometer_fill_overlay_numbers_kmh.cpp image_speedometer_fill_overlay_numbers_mph.cpp image_compass_arrow.cpp image_neochrom_button_on.cpp image_standard_button_normal.cpp
    libraries/touchgfx_lib/TouchGFX/generated/images/src/svg-screen/: image_icecream_next_normal.cpp image_waffle_menu_cone_small.cpp image_waffle_menu_cone_medium.cpp image_icecream_prevoius_normal.cpp image_ice_cream_backgrond_with_shadow.cpp image_waffle_menu_cone_large.cpp image_icecream_back_button_pressed.cpp image_waffle_menu_title.cpp image_icecream_prevoius_pressed.cpp image_icecream_back_button_normal.cpp image_icecream_next_pressed.cpp image_waffle_menu_expand.cpp
    libraries/touchgfx_lib/TouchGFX/generated/images/src/menu-launcher-screen/: image_menu_background.cpp image_preview_compass.cpp image_preview_dice.cpp image_preview_ebike.cpp image_preview_mjpeg.cpp image_preview_svg.cpp image_preview_transitions.cpp
    libraries/touchgfx_lib/TouchGFX/generated/gui_generated/src/containers/: WaffleMenuContainerBase.cpp scaleSliderContainer_DiceDemoBase.cpp IceScoopItemContainer_SVGBase.cpp FrameRate_E_BikeBase.cpp FrameRate_SVGBase.cpp transitionItem_ScreenTransitionBase.cpp topbarContainerBase.cpp cubeLeftRightButtonsContainer_DiceDemoBase.cpp MainWheelBase.cpp MainWheelIconBase.cpp AdvanceDiceContainer_DiceDemoBase.cpp selectedIconsContainer_DiceDemoBase.cpp MCULoadPercentage_CompassBase.cpp animationButton_ScreenTransitionBase.cpp animationsDepthButton_DiceDemoBase.cpp IceScoopWheelContainer_SVGBase.cpp bottombarContainer_ScreenTransitionBase.cpp MCULoadPercentage_E_BikeBase.cpp WaffleMenuIconBase.cpp FrameRate_MenuBase.cpp topbarContainer_ScreenTransitionBase.cpp cubeUpDownButtonsContainer_DiceDemoBase.cpp MCULoadPercentage_SVGBase.cpp MCULoadPercentage_MenuBase.cpp SimpleDiceContainer_DiceDemoBase.cpp FrameRate_CompassBase.cpp
    libraries/touchgfx_lib/TouchGFX/generated/images/src/Main/: image_mjpeg_icon_selected.cpp image_ebike_icon_selected.cpp image_confirm_button_pressed.cpp image_dice_icon_normal.cpp image_svg_icon_selected.cpp image_dice_icon_selected.cpp image_mjpeg_icon_normal.cpp image_confirm_button_active.cpp image_compass_icon_normal.cpp image_svg_icon_normal.cpp image_confirm_button_inactive.cpp image_ebike_icon_normal.cpp image_transitions_icon_normal.cpp image_transitions_icon_selected.cpp image_compass_icon_selected.cpp
    libraries/touchgfx_lib/TouchGFX/generated/images/src/: image_icon_back_24_pressed.cpp SVGDatabase.cpp BitmapDatabase.cpp image_icon_back_24_normal.cpp
    libraries/touchgfx_lib/TouchGFX/generated/gui_generated/src/screentransitiondemo_screen/: ScreenTransitionDemoViewBase.cpp
    libraries/touchgfx_lib/TouchGFX/generated/gui_generated/src/svg_screen/: SVGViewBase.cpp
    libraries/touchgfx_lib/TouchGFX/generated/images/src/compass-screen/: image_neochrom_switch_compass.cpp image_back_button_pressed_compass.cpp image_back_button_normal_compass.cpp image_Ellipse.cpp image_compass_background_480_Viper.cpp image_neochrom_off.cpp image_neochrom_on.cpp image_compass_disc_Viper.cpp
    libraries/touchgfx_lib/TouchGFX/generated/videos/src/keil/: Videos.s
    libraries/touchgfx_lib/TouchGFX/generated/gui_generated/src/dicedemo_screen/: DiceDemoViewBase.cpp
    libraries/touchgfx_lib/TouchGFX/generated/gui_generated/src/videointro_screen/: VideoIntroViewBase.cpp
    libraries/touchgfx_lib/TouchGFX/generated/texts/src/: Texts.cpp LanguageGb.cpp TypedTextDatabase.cpp
    libraries/touchgfx_lib/TouchGFX/generated/gui_generated/src/menu_screen/: MenuViewBase.cpp
    libraries/touchgfx_lib/TouchGFX/generated/gui_generated/src/mjpeg_screen/: MJPEGViewBase.cpp
    libraries/touchgfx_lib/TouchGFX/generated/gui_generated/src/e_bikedemo_screen/: E_BikeDemoViewBase.cpp
    libraries/touchgfx_lib/TouchGFX/generated/images/src/video-intro/: image_last_video_frame.cpp
    libraries/touchgfx_lib/TouchGFX/generated/gui_generated/src/compassscreen_screen/: CompassScreenViewBase.cpp
    libraries/touchgfx_lib/TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group TouchGFX/gui
    libraries/touchgfx_lib/TouchGFX/gui/src/svg_screen/: SVGView.cpp SVGPresenter.cpp
    libraries/touchgfx_lib/TouchGFX/gui/src/common/: FloatEasingEquations.cpp FrontendApplication.cpp FrameRate.cpp MCULoadPercentage.cpp
    libraries/touchgfx_lib/TouchGFX/gui/src/Transitions/: SlideTransition.cpp CurtainsTransition.cpp CoverTransition.cpp RolloutTransition.cpp SpinTransition.cpp FlipTransition.cpp CubeTransition.cpp SpinOutTransition.cpp Transitions.cpp
    libraries/touchgfx_lib/TouchGFX/gui/src/mjpeg_screen/: MJPEGPresenter.cpp MJPEGView.cpp
    libraries/touchgfx_lib/TouchGFX/gui/src/containers/: topbarContainer_ScreenTransition.cpp IceScoopItemContainer_SVG.cpp selectedIconsContainer_DiceDemo.cpp AdvanceDiceContainer_DiceDemo.cpp MCULoadPercentage_E_Bike.cpp MainWheelIcon.cpp cubeUpDownButtonsContainer_DiceDemo.cpp IceScoopWheelContainer_SVG.cpp MCULoadPercentage_Menu.cpp MainWheel.cpp FrameRate_E_Bike.cpp SimpleDiceContainer_DiceDemo.cpp WaffleMenuContainer.cpp MCULoadPercentage_Compass.cpp MCULoadPercentage_SVG.cpp animationsDepthButton_DiceDemo.cpp animationButton_ScreenTransition.cpp bottombarContainer_ScreenTransition.cpp transitionItem_ScreenTransition.cpp topbarContainer.cpp FrameRate_Compass.cpp FrameRate_Menu.cpp scaleSliderContainer_DiceDemo.cpp WaffleMenuIcon.cpp FrameRate_SVG.cpp cubeLeftRightButtonsContainer_DiceDemo.cpp
    libraries/touchgfx_lib/TouchGFX/gui/src/compassscreen_screen/: CompassScreenPresenter.cpp CompassScreenView.cpp
    libraries/touchgfx_lib/TouchGFX/gui/src/screentransitiondemo_screen/: ScreenTransitionDemoPresenter.cpp ScreenTransitionDemoView.cpp
    libraries/touchgfx_lib/TouchGFX/gui/src/dicedemo_screen/: DiceDemoView.cpp DiceDemoPresenter.cpp
    libraries/touchgfx_lib/TouchGFX/gui/src/menu_screen/: MenuView.cpp MenuPresenter.cpp
    libraries/touchgfx_lib/TouchGFX/gui/src/e_bikedemo_screen/: E_BikeDemoView.cpp E_BikeDemoPresenter.cpp
    libraries/touchgfx_lib/TouchGFX/gui/src/videointro_screen/: VideoIntroView.cpp VideoIntroPresenter.cpp
    libraries/touchgfx_lib/TouchGFX/gui/src/model/: Model.cpp
  group TouchGFX/Middlewares/rtt
    libraries/touchgfx_lib/Middlewares/Third_Party/CMSIS_RTOS_V2/: cmsis_os2.c
  group TouchGFX/target
    libraries/touchgfx_lib/TouchGFX/target/generated/: OSWrappers.cpp TouchGFXGeneratedHAL.cpp HardwareMJPEGDecoder.cpp nema_hal.c TouchGFXConfiguration.cpp STM32DMA.cpp
    libraries/touchgfx_lib/TouchGFX/target/: TouchGFXGPIO.cpp STM32TouchController.cpp TouchGFXHAL.cpp CortexMMCUInstrumentation.cpp
