# Keil uVision project CubeMX_Config_Appli.uvprojx, settings and files
target CubeMX_Config_Appli (6140001::V6.14.1::ARMCLANG)
  device: STM32H7S7L8HxH STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x24000000-0x24071BFF) IROM(0x8000000-0x800FFFF)  CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: CubeMX_Config_Appli +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7S7xx
  c include: ../../Appli/Core/Inc;../../Drivers/STM32H7RSxx_HAL_Driver/Inc;../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy;../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include;../../Drivers/CMSIS/Include;../../Appli/TouchGFX/App;../../Appli/TouchGFX/target/generated;../../Appli/TouchGFX/target
  scatter file: stm32h7s7xx_flash.sct
  link misc: --diag_suppress L6312,L6314
  group Application/MDK-ARM
    ../: startup_stm32h7s7xx.s
  group Application/User/Appli/Core
    ../../Appli/Core/Src/: main.c stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c stm32h7rsxx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../../Appli/Core/Src/: system_stm32h7rsxx.c
  group Application/User/Appli/TouchGFX/target
    ./: 
    ../../Appli/TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/Appli/TouchGFX/target/generated
    ./: 
    ../../Appli/TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp HardwareMJPEGDecoder.cpp nema_hal.c
  group Application/User/Appli/TouchGFX/App
    ./: 
    ../../Appli/TouchGFX/App/: app_touchgfx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ./: 
    ../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_crc.c stm32h7rsxx_hal_crc_ex.c stm32h7rsxx_hal_dma2d.c stm32h7rsxx_hal_gpu2d.c stm32h7rsxx_hal_i2c.c stm32h7rsxx_hal_i2c_ex.c stm32h7rsxx_hal_smbus.c stm32h7rsxx_hal_smbus_ex.c stm32h7rsxx_hal_icache.c stm32h7rsxx_hal_jpeg.c stm32h7rsxx_hal_ltdc.c stm32h7rsxx_hal_ltdc_ex.c
software components: CMSIS:CORE 5.6.0
