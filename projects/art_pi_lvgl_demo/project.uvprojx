# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32H7S7xx, RT_USING_ARMLIBC, STM32H7RS, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__
  c include: rt-thread\components\drivers\include;applications\lvgl_port;packages\LVGL-v8.3.11\src\extra\libs\fsdrv;packages\LVGL-v8.3.11\src\extra\libs\rlottie;packages\LVGL-v8.3.11\src\extra\libs\qrcode;packages\LVGL-v8.3.11\src\extra\widgets\spinner;packages\LVGL-v8.3.11\examples\libs\rlottie;rt-thread\components\libc\posix\io\eventfd;applications;packages\LVGL-v8.3.11\src\extra\libs\sjpg;rt-thread\components\drivers\spi\sfud\inc;board\CubeMX_Config\Appli\Core\Inc;rt-thread\libcpu\arm\cortex-m7;packages\LVGL-v8.3.11\src\extra\widgets\list;packages\LVGL-v8.3.11\src\extra\libs\freetype;rt-thread\components\libc\posix\ipc;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\dfs\dfs_v1\include;packages\LVGL-v8.3.11\examples\layouts;packages\LVGL-v8.3.11\src\extra\others\gridnav;packages\LVGL-v8.3.11\examples\layouts\flex;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\draw\swm341_dma2d;libraries\samples;packages\LVGL-v8.3.11\src\draw\stm32_dma2d;libraries\drivers\include;packages\LVGL-v8.3.11\src\extra\others\msg;packages\LVGL-v8.3.11\src\extra;packages\LVGL-v8.3.11\src\draw\nxp\pxp;rt-thread\components\dfs\dfs_v1\filesystems\romfs;packages\gt9147-v1.1.0\inc;packages\LVGL-v8.3.11\src\extra\libs;packages\LVGL-v8.3.11\src\extra\others\imgfont;packages\LVGL-v8.3.11\demos\benchmark;libraries\drivers;packages\LVGL-v8.3.11\src\extra\layouts\flex;packages\LVGL-v8.3.11\demos;packages\LVGL-v8.3.11\src\extra\widgets\colorwheel;packages\LVGL-v8.3.11\src\extra\widgets\msgbox;packages\LVGL-v8.3.11\src\extra\libs\gif;packages\LVGL-v8.3.11\src\extra\libs\tiny_ttf;packages\LVGL-v8.3.11\examples\libs\png;packages\LVGL-v8.3.11\src\draw\renesas;packages\LVGL-v8.3.11\src\core;packages\LVGL-v8.3.11\src\extra\widgets\menu;packages\LVGL-v8.3.11\src\font;packages\LVGL-v8.3.11\examples\others\monkey;packages\LVGL-v8.3.11\src\extra\widgets\imgbtn;packages\LVGL-v8.3.11\src\extra\widgets\win;rt-thread\components\finsh;packages\LVGL-v8.3.11\env_support\rt-thread;packages\LVGL-v8.3.11\demos\music\assets;packages\LVGL-v8.3.11\src\extra\widgets\led;packages\LVGL-v8.3.11\examples\porting;packages\LVGL-v8.3.11\src\extra\libs\ffmpeg;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\epoll;packages\LVGL-v8.3.11\examples\anim;packages\LVGL-v8.3.11\src\extra\widgets\tabview;packages\LVGL-v8.3.11\examples\libs\sjpg;packages\LVGL-v8.3.11\src\extra\widgets\tileview;packages\LVGL-v8.3.11\src\extra\widgets;libraries\CMSIS\Include;packages\LVGL-v8.3.11\examples\libs;packages\LVGL-v8.3.11\examples\libs\gif;packages\LVGL-v8.3.11\src\extra\themes\basic;packages\LVGL-v8.3.11\examples\others\fragment;packages\LVGL-v8.3.11\src\extra\layouts\grid;packages\LVGL-v8.3.11\examples\event;rt-thread\components\drivers\include;packages\LVGL-v8.3.11\demos\keypad_encoder;packages\LVGL-v8.3.11\src\hal;packages\LVGL-v8.3.11\src\extra\widgets\spinbox;rt-thread\components\drivers\spi;packages\LVGL-v8.3.11\src\draw\sw;packages\LVGL-v8.3.11\src\extra\themes\mono;libraries\bsp_components;rt-thread\components\libc\posix\io\poll;rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\libs\png;packages\LVGL-v8.3.11\src\draw;packages\LVGL-v8.3.11\src\draw\arm2d;packages\LVGL-v8.3.11\examples\others;packages\LVGL-v8.3.11\examples\others\ime;libraries\drivers\include\config;packages\LVGL-v8.3.11\src\extra\others\monkey;rt-thread\components\drivers\include;.;packages\LVGL-v8.3.11\src\extra\libs\bmp;rt-thread\components\libc\compilers\common\extension;packages\LVGL-v8.3.11\src\extra\others\ime;packages\LVGL-v8.3.11\examples\libs\qrcode;packages\LVGL-v8.3.11\demos\widgets;packages\LVGL-v8.3.11\examples\others\gridnav;packages\LVGL-v8.3.11\src\extra\others\snapshot;packages\LVGL-v8.3.11\src\extra\widgets\keyboard;packages\LVGL-v8.3.11\src\extra\others;packages\LVGL-v8.3.11\examples\others\snapshot;packages\LVGL-v8.3.11\src\extra\themes;packages\LVGL-v8.3.11\examples\layouts\grid;rt-thread\include;packages\LVGL-v8.3.11\src\extra\others\fragment;packages\LVGL-v8.3.11\examples\libs\bmp;board;packages\LVGL-v8.3.11\src\extra\widgets\chart;board\port;rt-thread\components\drivers\include;libraries\STM32H7RSxx_HAL_Driver\Inc;packages\LVGL-v8.3.11\src\widgets;packages\LVGL-v8.3.11\examples\styles;packages\LVGL-v8.3.11\examples\libs\ffmpeg;packages\LVGL-v8.3.11\examples\scroll;packages\LVGL-v8.3.11\src;packages\LVGL-v8.3.11\examples\libs\freetype;rt-thread\components\drivers\touch;packages\LVGL-v8.3.11\src\draw\nxp\vglite;packages\LVGL-v8.3.11\examples;packages\LVGL-v8.3.11\src\extra\widgets\meter;packages\LVGL-v8.3.11\examples\others\msg;libraries\CMSIS\Device\ST\STM32H7RSxx\Include;packages\LVGL-v8.3.11\demos\stress;packages\LVGL-v8.3.11\src\extra\widgets\calendar;packages\LVGL-v8.3.11\demos\music;packages\LVGL-v8.3.11\src\extra\widgets\animimg;packages\LVGL-v8.3.11\src\extra\layouts;rt-thread\libcpu\arm\common;packages\LVGL-v8.3.11\examples\others\imgfont;packages\LVGL-v8.3.11\src\draw\sdl;packages\LVGL-v8.3.11\examples\widgets;packages\LVGL-v8.3.11\src\misc;rt-thread\components\dfs\dfs_v1\filesystems\devfs;packages\LVGL-v8.3.11\src\extra\widgets\span;packages\LVGL-v8.3.11\src\extra\themes\default;packages\LVGL-v8.3.11\examples\get_started
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/touch/: touch.c
  group Drivers
    board/CubeMX_Config/Appli/Core/Src/: stm32h7rsxx_hal_msp.c
    board/: board.c drv_mpu.c
    board/port/: filesystem.c
    libraries/drivers/: drv_common.c drv_gpio.c drv_lcd.c drv_psram.c drv_sdio.c drv_soft_i2c.c drv_spi.c drv_usart.c drv_wlan.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group gt9147
    packages/gt9147-v1.1.0/src/: gt9147.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group LVGL
    packages/LVGL-v8.3.11/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    packages/LVGL-v8.3.11/examples/widgets/table/: lv_example_table_2.c lv_example_table_1.c
    packages/LVGL-v8.3.11/src/font/: lv_font.c lv_font_montserrat_28.c lv_font_montserrat_30.c lv_font_montserrat_34.c lv_font_fmt_txt.c lv_font_montserrat_36.c lv_font_montserrat_26.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_40.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_32.c lv_font_montserrat_8.c lv_font_montserrat_18.c lv_font_montserrat_10.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_montserrat_14.c lv_font_unscii_8.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_20.c lv_font_montserrat_28_compressed.c lv_font_montserrat_22.c lv_font_montserrat_38.c lv_font_loader.c lv_font_montserrat_16.c lv_font_montserrat_24.c
    packages/LVGL-v8.3.11/src/widgets/: lv_dropdown.c lv_label.c lv_checkbox.c lv_line.c lv_img.c lv_switch.c lv_btn.c lv_btnmatrix.c lv_table.c lv_roller.c lv_textarea.c lv_objx_templ.c lv_slider.c lv_arc.c lv_bar.c lv_canvas.c
    packages/LVGL-v8.3.11/src/draw/sw/: lv_draw_sw_gradient.c lv_draw_sw_line.c lv_draw_sw_rect.c lv_draw_sw_polygon.c lv_draw_sw_letter.c lv_draw_sw_dither.c lv_draw_sw_layer.c lv_draw_sw_img.c lv_draw_sw_transform.c lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c
    packages/LVGL-v8.3.11/examples/scroll/: lv_example_scroll_6.c lv_example_scroll_4.c lv_example_scroll_3.c lv_example_scroll_2.c lv_example_scroll_1.c lv_example_scroll_5.c
    packages/LVGL-v8.3.11/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.3.11/examples/libs/gif/: lv_example_gif_1.c img_bulb_gif.c
    packages/LVGL-v8.3.11/examples/widgets/btn/: lv_example_btn_2.c lv_example_btn_3.c lv_example_btn_1.c
    packages/LVGL-v8.3.11/examples/widgets/obj/: lv_example_obj_1.c lv_example_obj_2.c
    packages/LVGL-v8.3.11/demos/music/assets/: img_lv_demo_music_btn_play_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_wave_top.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_btn_play.c img_lv_demo_music_slider_knob.c img_lv_demo_music_cover_1.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_corner_large.c img_lv_demo_music_logo.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_corner_left.c img_lv_demo_music_cover_2.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_btn_pause.c
    packages/LVGL-v8.3.11/src/draw/: lv_draw_layer.c lv_draw.c lv_draw_img.c lv_draw_arc.c lv_draw_line.c lv_draw_label.c lv_draw_triangle.c lv_img_decoder.c lv_draw_mask.c lv_draw_rect.c lv_img_buf.c lv_img_cache.c lv_draw_transform.c
    packages/LVGL-v8.3.11/src/misc/: lv_style.c lv_tlsf.c lv_log.c lv_txt_ap.c lv_async.c lv_style_gen.c lv_ll.c lv_templ.c lv_area.c lv_bidi.c lv_fs.c lv_lru.c lv_anim.c lv_mem.c lv_color.c lv_gc.c lv_txt.c lv_math.c lv_anim_timeline.c lv_timer.c lv_utils.c lv_printf.c
    packages/LVGL-v8.3.11/examples/layouts/grid/: lv_example_grid_1.c lv_example_grid_2.c lv_example_grid_5.c lv_example_grid_3.c lv_example_grid_4.c lv_example_grid_6.c
    packages/LVGL-v8.3.11/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.11/examples/libs/png/: lv_example_png_1.c img_wink_png.c
    packages/LVGL-v8.3.11/examples/widgets/textarea/: lv_example_textarea_1.c lv_example_textarea_3.c lv_example_textarea_2.c
    packages/LVGL-v8.3.11/demos/benchmark/assets/: lv_font_bechmark_montserrat_12_compr_az.c.c img_benchmark_cogwheel_indexed16.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_rgb565a8.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c
    packages/LVGL-v8.3.11/src/draw/sdl/: lv_draw_sdl_utils.c lv_draw_sdl_label.c lv_draw_sdl.c lv_draw_sdl_texture_cache.c lv_draw_sdl_arc.c lv_draw_sdl_mask.c lv_draw_sdl_composite.c lv_draw_sdl_stack_blur.c lv_draw_sdl_line.c lv_draw_sdl_bg.c lv_draw_sdl_img.c lv_draw_sdl_layer.c lv_draw_sdl_rect.c lv_draw_sdl_polygon.c
    packages/LVGL-v8.3.11/examples/others/gridnav/: lv_example_gridnav_2.c lv_example_gridnav_4.c lv_example_gridnav_3.c lv_example_gridnav_1.c
    packages/LVGL-v8.3.11/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.11/examples/widgets/imgbtn/: lv_example_imgbtn_1.c
    packages/LVGL-v8.3.11/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.11/src/extra/libs/sjpg/: tjpgd.c lv_sjpg.c
    packages/LVGL-v8.3.11/src/draw/renesas/: lv_gpu_d2_ra6m3.c lv_gpu_d2_draw_label.c
    packages/LVGL-v8.3.11/src/draw/nxp/vglite/: lv_vglite_buf.c lv_draw_vglite_arc.c lv_draw_vglite_line.c lv_vglite_utils.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_draw_vglite.c
    packages/LVGL-v8.3.11/examples/event/: lv_example_event_3.c lv_example_event_1.c lv_example_event_4.c lv_example_event_2.c
    packages/LVGL-v8.3.11/examples/libs/rlottie/: lv_example_rlottie_2.c lv_example_rlottie_1.c lv_example_rlottie_approve.c
    packages/LVGL-v8.3.11/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.11/examples/widgets/bar/: lv_example_bar_2.c lv_example_bar_5.c lv_example_bar_3.c lv_example_bar_4.c lv_example_bar_6.c lv_example_bar_1.c
    packages/LVGL-v8.3.11/examples/styles/: lv_example_style_15.c lv_example_style_11.c lv_example_style_12.c lv_example_style_5.c lv_example_style_7.c lv_example_style_9.c lv_example_style_1.c lv_example_style_13.c lv_example_style_6.c lv_example_style_4.c lv_example_style_2.c lv_example_style_8.c lv_example_style_10.c lv_example_style_3.c lv_example_style_14.c
    packages/LVGL-v8.3.11/src/extra/libs/fsdrv/: lv_fs_stdio.c lv_fs_posix.c lv_fs_littlefs.c lv_fs_win32.c lv_fs_fatfs.c
    packages/LVGL-v8.3.11/examples/others/monkey/: lv_example_monkey_1.c lv_example_monkey_2.c lv_example_monkey_3.c
    packages/LVGL-v8.3.11/examples/widgets/roller/: lv_example_roller_1.c lv_example_roller_3.c lv_example_roller_2.c
    packages/LVGL-v8.3.11/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.3.11/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.11/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    packages/LVGL-v8.3.11/examples/widgets/chart/: lv_example_chart_2.c lv_example_chart_6.c lv_example_chart_7.c lv_example_chart_1.c lv_example_chart_3.c lv_example_chart_9.c lv_example_chart_4.c lv_example_chart_8.c lv_example_chart_5.c
    packages/LVGL-v8.3.11/src/extra/others/fragment/: lv_fragment_manager.c lv_fragment.c
    packages/LVGL-v8.3.11/examples/others/msg/: lv_example_msg_2.c lv_example_msg_3.c lv_example_msg_1.c
    packages/LVGL-v8.3.11/examples/assets/: img_star.c animimg001.c img_cogwheel_rgb.c img_hand.c animimg002.c imgbtn_left.c imgbtn_mid.c imgbtn_right.c img_cogwheel_alpha16.c img_cogwheel_argb.c animimg003.c img_cogwheel_chroma_keyed.c img_cogwheel_indexed16.c img_skew_strip.c img_caret_down.c
    packages/LVGL-v8.3.11/examples/widgets/btnmatrix/: lv_example_btnmatrix_3.c lv_example_btnmatrix_1.c lv_example_btnmatrix_2.c
    packages/LVGL-v8.3.11/examples/layouts/flex/: lv_example_flex_5.c lv_example_flex_3.c lv_example_flex_2.c lv_example_flex_1.c lv_example_flex_4.c lv_example_flex_6.c
    packages/LVGL-v8.3.11/examples/libs/freetype/: lv_example_freetype_1.c
    packages/LVGL-v8.3.11/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.11/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.11/src/core/: lv_obj.c lv_obj_draw.c lv_indev_scroll.c lv_theme.c lv_obj_style_gen.c lv_refr.c lv_obj_style.c lv_obj_tree.c lv_event.c lv_disp.c lv_group.c lv_indev.c lv_obj_class.c lv_obj_pos.c lv_obj_scroll.c
    packages/LVGL-v8.3.11/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    packages/LVGL-v8.3.11/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c lv_port_fs_template.c
    packages/LVGL-v8.3.11/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.11/examples/widgets/colorwheel/: lv_example_colorwheel_1.c
    packages/LVGL-v8.3.11/examples/widgets/dropdown/: lv_example_dropdown_2.c lv_example_dropdown_3.c lv_example_dropdown_1.c
    packages/LVGL-v8.3.11/examples/widgets/animimg/: lv_example_animimg_1.c
    packages/LVGL-v8.3.11/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.11/examples/widgets/keyboard/: lv_example_keyboard_1.c
    packages/LVGL-v8.3.11/examples/get_started/: lv_example_get_started_3.c lv_example_get_started_2.c lv_example_get_started_1.c
    packages/LVGL-v8.3.11/examples/widgets/calendar/: lv_example_calendar_1.c
    packages/LVGL-v8.3.11/demos/widgets/assets/: img_demo_widgets_avatar.c img_clothes.c img_lvgl_logo.c
    packages/LVGL-v8.3.11/examples/anim/: lv_example_anim_3.c lv_example_anim_2.c lv_example_anim_timeline_1.c lv_example_anim_1.c
    packages/LVGL-v8.3.11/examples/widgets/led/: lv_example_led_1.c
    packages/LVGL-v8.3.11/examples/widgets/line/: lv_example_line_1.c
    packages/LVGL-v8.3.11/src/hal/: lv_hal_tick.c lv_hal_indev.c lv_hal_disp.c
    packages/LVGL-v8.3.11/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.11/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.11/examples/widgets/list/: lv_example_list_1.c lv_example_list_2.c
    packages/LVGL-v8.3.11/src/extra/libs/gif/: lv_gif.c gifdec.c
    packages/LVGL-v8.3.11/examples/widgets/menu/: lv_example_menu_1.c lv_example_menu_2.c lv_example_menu_3.c lv_example_menu_5.c lv_example_menu_4.c
    packages/LVGL-v8.3.11/demos/music/: lv_demo_music.c lv_demo_music_main.c lv_demo_music_list.c
    packages/LVGL-v8.3.11/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.11/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.11/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.11/examples/widgets/checkbox/: lv_example_checkbox_1.c lv_example_checkbox_2.c
    packages/LVGL-v8.3.11/examples/widgets/label/: lv_example_label_5.c lv_example_label_2.c lv_example_label_4.c lv_example_label_1.c lv_example_label_3.c
    packages/LVGL-v8.3.11/examples/widgets/img/: lv_example_img_1.c lv_example_img_4.c lv_example_img_2.c lv_example_img_3.c
    packages/LVGL-v8.3.11/examples/widgets/tileview/: lv_example_tileview_1.c
    packages/LVGL-v8.3.11/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.11/examples/libs/bmp/: lv_example_bmp_1.c
    packages/LVGL-v8.3.11/examples/widgets/win/: lv_example_win_1.c
    packages/LVGL-v8.3.11/examples/libs/ffmpeg/: lv_example_ffmpeg_1.c lv_example_ffmpeg_2.c
    packages/LVGL-v8.3.11/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.11/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.11/examples/others/snapshot/: lv_example_snapshot_1.c
    packages/LVGL-v8.3.11/examples/widgets/canvas/: lv_example_canvas_1.c lv_example_canvas_2.c
    packages/LVGL-v8.3.11/examples/widgets/arc/: lv_example_arc_1.c lv_example_arc_2.c
    packages/LVGL-v8.3.11/examples/widgets/meter/: lv_example_meter_4.c lv_example_meter_3.c lv_example_meter_2.c lv_example_meter_1.c
    packages/LVGL-v8.3.11/examples/others/ime/: lv_example_ime_pinyin_1.c lv_example_ime_pinyin_2.c
    packages/LVGL-v8.3.11/examples/widgets/slider/: lv_example_slider_1.c lv_example_slider_2.c lv_example_slider_3.c
    packages/LVGL-v8.3.11/examples/others/fragment/: lv_example_fragment_1.c lv_example_fragment_2.c
    packages/LVGL-v8.3.11/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.11/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.11/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.11/examples/widgets/msgbox/: lv_example_msgbox_1.c
    packages/LVGL-v8.3.11/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.11/examples/libs/qrcode/: lv_example_qrcode_1.c
    packages/LVGL-v8.3.11/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.11/src/extra/: lv_extra.c
    packages/LVGL-v8.3.11/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.11/examples/widgets/spinner/: lv_example_spinner_1.c
    packages/LVGL-v8.3.11/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.11/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.11/examples/others/imgfont/: lv_example_imgfont_1.c
    packages/LVGL-v8.3.11/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.11/examples/widgets/switch/: lv_example_switch_1.c
    packages/LVGL-v8.3.11/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.11/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.11/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.11/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.11/examples/widgets/spinbox/: lv_example_spinbox_1.c
    packages/LVGL-v8.3.11/demos/stress/: lv_demo_stress.c
    packages/LVGL-v8.3.11/examples/widgets/tabview/: lv_example_tabview_2.c lv_example_tabview_1.c
    packages/LVGL-v8.3.11/examples/libs/sjpg/: lv_example_sjpg_1.c
    packages/LVGL-v8.3.11/examples/widgets/span/: lv_example_span_1.c
    packages/LVGL-v8.3.11/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.11/demos/widgets/: lv_demo_widgets.c
    packages/LVGL-v8.3.11/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    packages/LVGL-v8.3.11/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.11/demos/benchmark/: lv_demo_benchmark.c
    packages/LVGL-v8.3.11/examples/assets/emoji/: img_emoji_F617.c
  group LVGL-demo
    packages/lv_music_demo-v0.3.4/assets/: img_lv_demo_rtt_music_cover_1.c img_lv_demo_rtt_music_btn_list_play.c img_lv_demo_rtt_music_cover_3.c img_lv_demo_rtt_music_btn_play.c img_lv_demo_rtt_music_wave_top.c img_lv_demo_rtt_music_icon_2.c img_lv_demo_rtt_music_logo.c img_lv_demo_rtt_music_btn_prev.c img_lv_demo_rtt_music_icon_4.c img_lv_demo_rtt_music_btn_next.c img_lv_demo_rtt_music_btn_list_pause.c img_lv_demo_rtt_music_icon_1.c img_lv_demo_rtt_music_btn_loop.c img_lv_demo_rtt_music_icon_3.c img_lv_demo_rtt_music_cover_2.c img_lv_demo_rtt_music_corner_left.c img_lv_demo_rtt_music_corner_right.c img_lv_demo_rtt_music_list_border.c img_lv_demo_rtt_music_btn_rnd.c img_lv_demo_rtt_music_btn_pause.c img_lv_demo_rtt_music_wave_bottom.c img_lv_demo_rtt_music_slider_knob.c
    packages/lv_music_demo-v0.3.4/: lv_demo_rtt_music.c lv_demo_rtt_music_list.c lv_demo_rtt_music_main.c
  group LVGL-port
    applications/lvgl_port/: lv_demo.c lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.3.11/env_support/rt-thread/: lv_rt_thread_port.c
  group STM32_HAL
    libraries/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_cryp.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_ltdc.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_dma2d.c stm32h7rsxx_hal_cec.c stm32h7rsxx_hal_crc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_crc_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rng.c stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_sram.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_cryp_ex.c stm32h7rsxx_hal_usart.c
    libraries/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/arm/: startup_stm32h7s7xx.s
    libraries/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/: system_stm32h7rsxx.c
