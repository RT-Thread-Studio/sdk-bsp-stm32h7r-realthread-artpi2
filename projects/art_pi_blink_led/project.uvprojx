# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32H7S7xx, RT_USING_ARMLIBC, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__
  c include: ..\..\rt-thread\components\libc\posix\io\epoll;..\..\rt-thread\components\drivers\include;..\..\libraries\drivers\include;..\..\rt-thread\components\libc\posix\io\poll;board\CubeMX_Config\Appli\Core\Inc;..\..\libraries\samples;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\spi;..\..\libraries\CMSIS\Device\ST\STM32H7RSxx\Include;..\..\libraries\STM32H7RSxx_HAL_Driver\Inc;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\dfs\dfs_v1\filesystems\romfs;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\finsh;..\..\rt-thread\include;..\..\libraries\bsp_components;..\..\rt-thread\libcpu\arm\cortex-m7;..\..\rt-thread\components\libc\compilers\common\extension;..\..\libraries\CMSIS\Include;applications;..\..\libraries\drivers;..\..\rt-thread\components\dfs\dfs_v1\filesystems\devfs;..\..\libraries\drivers\include\config;..\..\rt-thread\components\drivers\spi\sfud\inc;..\..\rt-thread\components\libc\compilers\common\include;..\..\rt-thread\components\libc\posix\io\eventfd;board\port;board;..\..\rt-thread\components\dfs\dfs_v1\include;.;..\..\rt-thread\components\libc\posix\ipc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/core/: device.c
    ../../rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread/components/drivers/mtd/: mtd_nor.c
    ../../rt-thread/components/drivers/pin/: pin.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    board/CubeMX_Config/Appli/Core/Src/: stm32h7rsxx_hal_msp.c
    board/: board.c drv_mpu.c
    board/port/: filesystem.c
    ../../libraries/drivers/: drv_common.c drv_gpio.c drv_lcd.c drv_psram.c drv_sdio.c drv_spi.c drv_usart.c drv_wlan.c
  group Filesystem
    ../../rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../rt-thread/components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    ../../rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../rt-thread/libcpu/arm/common/: div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group STM32_HAL
    ../../libraries/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_cryp.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_cec.c stm32h7rsxx_hal_crc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_crc_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rng.c stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_sram.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_cryp_ex.c stm32h7rsxx_hal_usart.c
    ../../libraries/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/arm/: startup_stm32h7s7xx.s
    ../../libraries/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/: system_stm32h7rsxx.c
